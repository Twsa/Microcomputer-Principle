# Keil uVision project Lab5.uvproj, settings and files
target Lab3 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: Hex +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./User/: lab5.ASM
