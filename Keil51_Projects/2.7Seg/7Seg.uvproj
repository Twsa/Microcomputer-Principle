# Keil uVision project 7Seg.uvproj, settings and files
target 7seg (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 7Seg +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group User
    ./User/: 7seg.ASM
