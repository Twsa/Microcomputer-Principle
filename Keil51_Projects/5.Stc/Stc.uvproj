# Keil uVision project Stc.uvproj, settings and files
target hello (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  asm include: .\User
  group User
    ./User/: hello.ASM
