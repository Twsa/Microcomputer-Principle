# Keil uVision project ExcTest.uvproj, settings and files
target hello (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  asm include: .\User
  group User
    ./User/: test.ASM
